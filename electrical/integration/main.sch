File: electrical/integration/main.sch (EAGLE design)
At the start: 0 parts

Commit message: remove extraneous headers
Other:
- note removed: "No connections from GPIO Header to other modules"
